# IAR project uCOS-II.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\uCOS-II; ..\..\uCOS-II\Sakura_APP; ..\..\uCOS-II\Sakura_APP\cwProtocol; ..\..\uCOS-II\IAR; ..\..\BSP; ..\..\BSP\Sakura_BSP; ..\..\BSP\OS\uCOS-II; ..\..\BSP\ST\STM32F4xx\inc; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\uC-Serial\Driver\ST; ..\..\..\..\..\uC-Serial\Driver\ST\STM3240x; ..\..\..\..\..\uC-Serial\Line; ..\..\..\..\..\uC-Serial\OS; ..\..\..\..\..\uC-Serial\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: uCOS-II.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\STM32F4xx_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app.cpp appISR.cpp appTASK.cpp
  group APP/HeadFiles
    ./: app_cfg.h lib_cfg.h
    ../: cpu_cfg.h includes.h os_cfg.h stm32f4xx.h stm32f4xx_conf.h
  group APP/Low_Level_Design
    ../: app_hooks.c appISRlld.c appTASKlld.c
  group APP/Sakura_APP/Protocol/cwProtocol
    ../Sakura_APP/cwProtocol/: cwProtocol_L1.cpp cwProtocol_L2.cpp cwProtocol_L3.cpp
  group APP/Serial
    ../: app_serial.c app_serial.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
    ../../BSP/IAR/: cstartup.c STM32F4xx_FLASH.icf
  group BSP/OS
    ../../BSP/OS/uCOS-II/: bsp_os.c bsp_os.h
  group BSP/Sakura_BSP
    ../../BSP/Sakura_BSP/: skrUSART.c
  group BSP/ST/STM32F4xx/inc
    ../../BSP/ST/STM32F4xx/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group BSP/ST/STM32F4xx/src
    ../../BSP/ST/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../../../../uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-II/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../../uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/Serial/Driver/ST
    ../../../../../uC-Serial/Driver/ST/: serial_drv_stm32.c serial_drv_stm32.h
  group uC/Serial/Driver/ST/STM3240x
    ../../../../../uC-Serial/Driver/ST/STM3240x/: serial_bsp_stm3240x.c serial_bsp_stm3240x.h
  group uC/Serial/Line
    ../../../../../uC-Serial/Line/: serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h
  group uC/Serial/OS
    ../../../../../uC-Serial/OS/: serial_os.h
  group uC/Serial/OS/uCOS-II
    ../../../../../uC-Serial/OS/uCOS-II/: serial_os.c
  group uC/Serial/Source
    ../../../../../uC-Serial/Source/: serial.c serial.h serial_buf.c serial_buf.h serial_type.h
